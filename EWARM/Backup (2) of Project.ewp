# IAR project Backup (2) of Project.ewp, settings and files
configuration J_LINK (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\ssd1306\BSP; ..\Libraries\ssd1306\Driver; ..\Libraries\ssd1306\Lib; ..\Libraries\Si7021; ..\Libraries\BMP180; ..\Libraries\BMP280
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ST_LINK (ARM, debug)
  as the first configuration, except:
  group CMSIS
    ../: system_stm32f10x.c
  group EWARMv5
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Libs
    ../Libraries/ssd1306/Driver/: iic.c
  group Libs/BMP180
    ../Libraries/BMP180/: bmp180.c
  group Libs/BMP280
    ../Libraries/BMP280/: bmp280.c bmp280_user.c
  group Libs/Si7021
    ../Libraries/Si7021/: si7021.c
  group Libs/ssd1306
    ../Libraries/ssd1306/BSP/: display.c
    ../Libraries/ssd1306/Lib/: ssd1306.c ssd1306_fonts.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../: main.c stm32f10x_it.c
